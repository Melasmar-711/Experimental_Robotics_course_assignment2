Commit message: saved the mao

File: robot_model_and_simulation/urdf/mogi_bot.urdf (robot description, URDF)
Before this commit: robot mogi_bot, 9 links, 8 joints
Joints:
- joint scan_joint: origin (none) -> xyz=0 0 0.15 rpy=0 0 0
